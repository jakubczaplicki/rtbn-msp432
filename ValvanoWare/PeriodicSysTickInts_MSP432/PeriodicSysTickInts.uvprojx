# Keil uVision project PeriodicSysTickInts.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicSysTickInts
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./: SysTickInts.c PeriodicSysTickInts.c
  group ::Device
    RTE/Device/MSP432P401R/: startup_msp432.s system_msp432.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
